# Keil uVision project Project.uvprojx, settings and files
target DataLog_STM32L476RG_SensorTile (ARM-ADS)
  device: STM32L476JGYx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32L476RG_SensorTile +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: STM32L476xx,USE_HAL_DRIVER,ARM_MATH_CM4,__FPU_PRESENT=1
  c misc: --C99 --gnu --no_conditionalize
  c include: ..\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\..\Drivers\BSP\SensorTile;..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\Drivers\BSP\Components\lsm6dsm;..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\Drivers\BSP\Components\lps22hb;..\..\..\..\..\Drivers\BSP\Components\lsm303agr;..\..\..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers;..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\..\..\..\Drivers\BSP\Components\pcm1774
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Keil
    ./: startup_stm32l476xx.s
  group Drivers/Hal
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_sai.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/pcm1774/: PCM1774_CODEC_Driver.c
    ../../../../../Drivers/BSP/Components/lsm6dsm/: LSM6DSM_ACC_GYRO_driver.c LSM6DSM_ACC_GYRO_driver_HL.c
    ../../../../../Drivers/BSP/Components/lsm303agr/: LSM303AGR_ACC_driver.c LSM303AGR_ACC_driver_HL.c
  group Drivers/BSP/SensorTile
    ../../../../../Drivers/BSP/SensorTile/: SensorTile.c SensorTile_audio_out.c SensorTile_audio_in.c SensorTile_accelero.c
  group User
    ../Src/: cube_hal_l4.c main.c stm32l4xx_hal_msp.c stm32l4xx_it.c
  group Vox
    ../Vox/: vox.c pitch.c vox-memcpy.c
    ../vox/: vox-fft.c vox-eq.c
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6
